Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-04-27T18:14:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 27 18:14:10 2018 * Host: CHTSPC1011 * Database: C:\Users\163031\AppData\Local\Temp\{46F2F57B-9239-4B09-9B31-53F91AC98E83}\ifc * Database version: 5507 * Database creation date: Fri Apr 27 18:14:00 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 27 18:14:01 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 27 18:14:01 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcTransportElement: Stowed Position, 0010720_E300AJP_20180412:Stowed Position:387060
In: Level 1
Type - PredefinedType: ELEVATOR; Material: JLG_Plastic_Blue, JLG_Plastic_Green, JLG_Paint_Black, JLG_Plastic_Yellow, JLG_Steel, JLG_Metal Paint_White, JLG_Metal Paint_Black, JLG_Paint_Orange, JLG_Paint_Beige, switch(1), JLG_Plastic_Red, JLG_Rubber_Black, JLG_Plastic_Light Grey
Type - Constraints - A1a: -8 deg; A2a: -8 deg; AE: 21 mm; AEa: -11.66 deg; Ja: -60 deg; Jib Roation: 0 deg; Reach: 0
Type - Data - Batteries: 6v, 305 Ah x8; Brakes: Automatic Rear Wheel Brake; Drive Motors: 2.6kW Traction Drive x2; Drive Speed: 7.2 kph (4.5 mph); Electrical System: 48v DC; Gradeability: 25%; Ground Clearance: 0.1 m (0 ft 4 in); Horizontal Outreach: 6.12 m (20 ft 1 in); Hydraulic Motor: 48v, Perm Magnet; Hydraulic Pump: 2 Gpm; Hydraulic Reservoir: 11 L (2.9 gal); Jib - Overall Length: 1.22 m (4 ft); Jib Range of Articulation: 144 Degrees (+84°/-60°); Machine weight (ANSI): 6985 kg (8200 lbs); Machine weight (CE): 6985 kg (8200 lbs); Max Ground Bearing Pressure (ANSI): 11.95 kg/cm2 (170 psi); Max Ground Bearing Pressure (CE): 11.95 kg/cm2 (170 psi); Model Name: E300AJP; Platform Capacity Unrestricted (ANSI): 227 Kg (500 lbs.); Platform Capacity Unrestricted (CE): 230 Kg (507 lbs.); Platform Height: 8.97 m (29 ft 5 in); Platform Rotator (Hydraulic): 180 Degrees; Platform Size: 0.76 x 1.22 m (2 ft 6 in x 4 ft 0 in); Swing: 350 Degrees Non Continuous; Turning Radius Inside: 1.52 m (5 ft 0 in); Turning Radius Outside: 3.10 m ( 10 ft 2 in); Tyres: 25x7x12 Solid Non-Marking; Up and Over Height: 4.01 m (13 ft 2 in)
Type - Dimensions - A1a1: 172 deg; A2a1: 172 deg; AEa1: 168.34 deg; AEHa: -8 deg; AEHa1: 172 deg; AHa: 8 deg; AHa1: 188 deg; Ja1: 120 deg; JHa: 11.66 deg; JHa1: 191.66 deg; PHa: 60 deg; PHa1: 240 deg
Type - General - Articulating Jib: 1.22 m articulating jib; Platform Rotator .: 180 degree powered platform rotator; Platform Side Entry: 0.76 m x 1.22 m low mount platform; Tilt Alarm/Indicator Light: 3 Degrees = CE/AUS, 5 Degrees Japan
Type - Identity Data - Manufacturer: JLG; OmniClass Number: 23.40.00.00; OmniClass Title: Equipment and Furnishings; Type Name: Stowed Position; URL: https://www.jlg.com
Type - Model Properties - _Author: n/a; _AuthorizedBy: n/a; _BIMspec_GUID: n/a; _BimSpecGuid: n/a; _BSBibleVersion: n/a; _CreatedBy: JLG; _CurrentRevision: 0; _DistributedBy: JLG; BIMObjectName: 0010720_E300AJP; NBSDescription: Articulating Boom Lift; NBSNote: n/a; NBSObjectName: JLG E300AJP_Articulating Boom Lift; NBSOfficeMasterTag: n/a; NBSReference: n/a
Type - Other - Category: Mechanical Equipment; AccessibilityPerformance: n/a; AssetIdentifier (default): Please Record On Commissioning; AssetType: Elevators; BarCode (default): Please Record On Commissioning; ClassificationName: n/a; ClassificationValue: n/a; CodePerformance: n/a; Color: n/a; Constituents: n/a; CreatedBy: JLG (https://www.jlg.com/en); CreatedOn: 2018; DocumentationCertificates: n/a; DocumentationInstallationGuide: n/a; DocumentationLiterature: n/a; DocumentationMaintenance: n/a; DocumentationTechnical: n/a; DurationUnit: Years; ExpectedLife: n/a; Family Name: 0010720_E300AJP_20180412; Features: n/a; Finish: n/a; Grade: n/a; InstallationDate (default): n/a; ManufacturerName: JLG (https://www.jlg.com/en); Material: n/a; ModelNumber: E300AJP; ModelReference: JLG - Articulating Boom Lift; ProductionYear: n/a; ReferencedStandard: n/a; ReplacementCost: n/a; SerialNumber (default): Please Record On Commissioning; Shape: n/a; Size: n/a; SpareParts: n/a; TypeName: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.jlg.com; WarrantyGuarantorParts: https://www.jlg.com
OperationType: ELEVATOR; CapacityByWeight: 0 kg; CapacityByNumber: 0
Pset_ManufacturerTypeInformation - ModelReference: JLG - Articulating Boom Lift; Manufacturer: JLG; ProductionYear: n/a
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 234 m2; Platform Rotation: 0 deg; PR: 0 deg; Reach Diagram: no; Sa1: 180 deg; Swing_A: 0 deg; Swing_Angle: 0 deg; Turning Radius: no; Volume: 1.81357 m3; Working Area: no
Identity Data - Mark: 3
Other - Family: 0010720_E300AJP_20180412: Stowed Position; Family and Type: 0010720_E300AJP_20180412: Stowed Position; Type: 0010720_E300AJP_20180412: Stowed Position; Type Id: 0010720_E300AJP_20180412: Stowed Position; WarrantyStartDate (default): Please Record On Commissioning
Phasing - Phase Created: New Construction
